# Keil uVision project Release.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Release
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\User;..\GD32F10x_Firmware_Library\Firmware\Peripherals\inc;..\GD32F10x_Firmware_Library\Firmware\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c gd32f10x_it.c uart.c delay.c nRF24L01.c spi.c dht11.c relay.c
  group CMSIS
    ../GD32F10x_Firmware_Library/Firmware/CMSIS/: core_cm3.c system_gd32f10x.c
  group GD32F10x_Peripherals
    ../GD32F10x_Firmware_Library/Firmware/Peripherals/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group Startup
    ../GD32F10x_Firmware_Library/Firmware/: startup_gd32f10x_hd.s
